# Keil uVision project ServiceRobot.uvprojx, settings and files
target ServiceRobot_LeiShen (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Robot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\dma;..\STMicroelectronics\STM32F10x_FWLib\inc;..\STMicroelectronics;..\CORE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SRC\Drivers;..\SRC\include;..\SRC\Communication;..\SRC\RunControl;..\SRC\Drivers\MPU5060;..\SRC\Drivers\L3G4200;..\SRC\MotorContrl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./: main.c CarParameterSet.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group MPU6050
    ../SRC/Drivers/MPU5060/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c mpu6050manage.c myiic.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group STMicroelectronics
    ../STMicroelectronics/STM32F10x_FWLib/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
    ../STMicroelectronics/: stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/dma/: dma.c
  group Drivers
    ../SRC/Drivers/: DriversMain.c GPIO_Config.c MotorControl.c encoder.c
  group RobotRun
    ../SRC/RunControl/: RobotRunControlMain.c RunDeal.c
  group Communication
    ../SRC/Communication/: CommunicationMain.c protocol.c check.c
  group README
    ../: README.TXT
  group MotorControl
    ../SRC/MotorContrl/: hub_motor.c RS485.c
